Commit message: ball model changed, restitution as cfg

File: basketball.urdf (robot description, URDF)
Before this commit: robot basketball, 3 links, 1 joints
Links:
- link ball: mass 0.62 -> 0.5
